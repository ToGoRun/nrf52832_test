# Keil uVision project project.uvprojx, settings and files
target rtthread (6190000::V6.19::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: __STDC_LIMIT_MACROS, NRF52832_XXAA, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_APP_CONFIG, RT_USING_ARM_LIBC
  c include: .;applications;libraries\cmsis\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;libraries\drivers;rt-thread\components\fal\inc;rt-thread\components\finsh;.;rt-thread\include;packages\nrfx-latest;packages\nrfx-latest\drivers;packages\nrfx-latest\drivers\include;packages\nrfx-latest\mdk;packages\nrfx-latest\hal;packages\nrfx-latest\drivers\src;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\utest;rt-thread\components\utilities\ulog
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: board.c
    libraries/drivers/: drv_adc.c drv_flash.c drv_gpio.c drv_hwtimer.c drv_pwm.c drv_rtc.c drv_spi.c drv_uart.c drv_wdt.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_qspi.c nrfx_pwm.c nrfx_uart.c nrfx_saadc.c nrfx_pdm.c nrfx_timer.c nrfx_ipc.c nrfx_spis.c nrfx_rtc.c nrfx_usbd.c nrfx_ppi.c nrfx_spim.c nrfx_uarte.c nrfx_nfct.c nrfx_dppi.c nrfx_wdt.c nrfx_nvmc.c nrfx_twi.c nrfx_lpcomp.c nrfx_rng.c nrfx_spi.c nrfx_systick.c nrfx_i2s.c nrfx_twi_twim.c nrfx_gpiote.c nrfx_power.c nrfx_twis.c nrfx_qdec.c nrfx_usbreg.c nrfx_twim.c nrfx_comp.c nrfx_clock.c nrfx_temp.c nrfx_adc.c nrfx_egu.c
    packages/nrfx-latest/mdk/: system_nrf52.c
    ./packages/nrfx-latest/mdk/: arm_startup_nrf52.s
  group UTest
    rt-thread/components/utilities/utest/: utest.c
    ./applications/testcases/: flash_utest.c pin_utest.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
  group demo
    ./applications/demo/: flash_demo.c hwtimer_demo.c pin_demo.c rng_demo.c saadc_demo.c spi_demo.c uart_demo.c watchdog_demo.c
